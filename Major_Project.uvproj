# Keil uVision project Major_Project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Major_Project1234 +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s delay.c type.h Major_adc.h Major_adc_defines.h Major_adc_def.c pinconnect.c
  group LCD
    ./: Major_lcd.c Major_lcd.h
  group CAN
    ./: Major_Can.c Major_Can.h Major_candefines.h
  group EINT
    ./: Major_EINT.c neweint000.c
  group main
    ./: Major_main.c Major_mainnode.c siri_main_modif.c Major_mainnode1.c mma.c ind_main.c Major_mainfinal.c
  group DS18B20
    ./: Major_ds18b20_test.c Major_dsb18b20.h
  group Fule
    ./: Major_Fuel_def.c Major_Fuel.h major_fuel000.c aaaa.c today.c ok.c
